# Repository yswallow/satsuma_keyboard

File README.md:

### Satsuma JP SMD

#### 組み立てに必要なもの
* MX互換スイッチ 67個
* ARCHISS キーキャップセット 1セット

#### 各部名称

#### 組み立て方
1. キースイッチをトッププレートにはめる。この際上下が逆になっているキーがあるので注意する。
2. キースイッチがはまった状態のトッププレートを本体にはめる。
3. キースイッチにキーキャップをはめる。
4. 完成！

## KiCad design PCB/right/right-PCB.kicad_pcb

Board: 2 copper layers, 171.0 x 95.0 mm, 48 parts (8 on the bottom side), 44 nets.

Parts:
C1: C; C_2220_5650Metric_Pad1.97x5.40mm_HandSolder
D1: LED; LED_D3.0mm
J1, J2: Modulo-Jack; PJ-320D
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW32, SW33, SW37: SW_Push; MXOnly-1U-Hotswap
SW17: SW_Push; MXOnly-ISO-HotSwap
SW31: SW_Push; MXOnly-1.75U-Hotswap
SW34, SW35, SW36, SW38: SW_Push; MXOnly-1.25U-Hotswap
SW50: SW_DIP_x04; KHS42
U1, U2, U3: MCP23017_SP; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
ADDR: R2.1, SW50.1, U1.17, U2.17, U3.17
GND: C1.2, J1.A, J2.A, R1.2, R2.2, SW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.1, SW17.1, SW18.1, SW19.1, SW20.1, SW21.2, SW22.2, SW23.2, SW24.2, SW25.2, SW26.2, SW27.1, SW28.1, SW29.2, SW30.1, SW31.2, SW32.1, SW33.1, SW34.2, SW35.2, SW36.2, SW37.2, SW38.1, U1.10, U1.15, U1.16, U2.10, U2.16, U3.10, U3.15
unnamed: D1.1, R1.1
SCL: J1.C, J2.C, U1.12, U2.12, U3.12
SDA: J1.B, J2.B, U1.13, U2.13, U3.13
SW1: SW1.2, U1.6
SW2: SW2.1, U1.5
SW3: SW3.1, U1.4
SW4: SW4.1, U1.3
SW5: SW5.1, U1.2
SW6: SW6.1, U1.1
SW7: SW7.1, U1.7
SW8: SW8.1, U1.8
SW9: SW9.1, U1.21
SW10: SW10.1, U1.24
SW11: SW11.1, U1.25
SW12: SW12.1, U1.26
SW13: SW13.1, U1.27
SW14: SW14.1, U1.28
SW15: SW15.1, U1.23
SW16: SW16.2, U1.22
SW17: SW17.2, U3.3
SW18: SW18.2, U2.2
SW19: SW19.2, U2.1
SW20: SW20.2, U2.3
SW21: SW21.1, U2.4
SW22: SW22.1, U3.2
SW23: SW23.1, U3.1
SW24: SW24.1, U3.4
SW25: SW25.1, U2.27
SW26: SW26.1, U2.26
SW27: SW27.2, U2.23
SW28: SW28.2, U2.21
SW29: SW29.1, U3.28
SW30: SW30.2, U3.26
SW31: SW31.1, U3.23
SW32: SW32.2, U2.28
SW33: SW33.2, U2.25
SW34: SW34.1, U2.24
SW35: SW35.1, U2.22
SW36: SW36.1, U3.27
SW37: SW37.1, U3.25
SW38: SW38.2, U3.24
VCC: C1.1, D1.2, J1.D, J2.D, SW50.8, U1.9, U1.18, U2.9, U2.15, U2.18, U3.9, U3.16, U3.18

## KiCad design PCB/left/left-PCB.kicad_pcb

Parts:
C1: C; C_2225_5664Metric_Pad1.80x6.60mm_HandSolder
D1, D2: LED; LED_D3.0mm
J1, J2: Modulo-Jack; TRRS_SMD_SJ2-3574A-SMT_ABCD
R1, R2, R3, R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21, SW22, SW23, SW24, SW26, SW28, SW30, SW31: SW_Push; MXOnly-1U-Hotswap
SW7: SW_Push; MXOnly-1.5U-Hotswap
SW13: SW_Push; MXOnly-1.75U-Hotswap
SW19: SW_Push; MXOnly-2.25U-Hotswap
SW25, SW27: SW_Push; MXOnly-1.25U-Hotswap
SW32: SW_Push; MXOnly-2U-Hotswap-ReversedStabilizers
SW50: SW_DIP_x04; KHS42
U1, U2: MCP23017_SP; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
A1: R4.1, SW50.2, U1.16 (A1), U2.16 (A1)
A2: R3.1, SW50.1, U1.17 (A2), U2.17 (A2)
Caps: D2.2 (A), U2.24 (GPA3)
GND: C1.2, D1.1 (K), J1.A (GND), J2.A (GND), R2.2, R3.2, R4.2, SW1.1, SW2.1, SW3.2, SW4.2, SW5.2, SW6.2, SW7.1, SW8.1, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.1, SW16.1, SW17.2, SW18.1, SW19.1, SW20.2, SW21.2, SW22.2, SW23.2, SW24.2, SW25.1, SW26.1, SW27.2, SW28.1, SW30.1, SW31.1, SW32.1, U1.10 (VSS), U1.15 (A0), U2.10 (VSS)
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), R2.1
SCL: J1.C (SCL), J2.C (SCL), U1.12 (SCL), U2.12 (SCL)
SDA: J1.B (SDA), J2.B (SDA), U1.13 (SDA), U2.13 (SDA)
SW1: SW1.2, U1.5 (GPB4)
SW2: SW2.2, U1.3 (GPB2)
SW3: SW3.1, U1.2 (GPB1)
SW4: SW4.1, U1.7 (GPB6)
SW5: SW5.1, U1.24 (GPA3)
SW6: SW6.1, U1.23 (GPA2)
SW7: SW7.2, U1.6 (GPB5)
SW8: SW8.2, U1.4 (GPB3)
SW9: SW9.1, U1.1 (GPB0)
SW10: SW10.1, U1.8 (GPB7)
SW11: SW11.1, U1.22 (GPA1)
SW12: SW12.1, U1.21 (GPA0)
SW13: SW13.1, U1.28 (GPA7)
SW14: SW14.1, U1.27 (GPA6)
SW15: SW15.2, U1.26 (GPA5)
SW16: SW16.2, U1.25 (GPA4)
SW17: SW17.1, U2.7 (GPB6)
SW18: SW18.2, U2.5 (GPB4)
SW19: SW19.2, U2.1 (GPB0)
SW20: SW20.1, U2.2 (GPB1)
SW21: SW21.1, U2.3 (GPB2)
SW22: SW22.1, U2.8 (GPB7)
SW23: SW23.1, U2.6 (GPB5)
SW24: SW24.1, U2.4 (GPB3)
SW25: SW25.2, U2.27 (GPA6)
SW26: SW26.2, U2.28 (GPA7)
SW27: SW27.1, U2.26 (GPA5)
SW28: SW28.2, U2.25 (GPA4)
SW30: SW30.2, U2.21 (GPA0)
SW31: SW31.2, SW32.2, U2.22 (GPA1)
VCC: C1.1, J1.D (3V3), J2.D (3V3), R1.1, SW50.7, SW50.8, U1.9 (VDD), U1.18 (~RESET~), U2.9 (VDD), U2.15 (A0), U2.18 (~RESET~)

Board: 2 copper layers, 137.8 x 95.0 mm, 43 parts (6 on the bottom side), 39 nets.

## KiCad design left/left.kicad_pcb

Parts:
C1: C; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D3.0mm
J1, J2, J3: Modulo-Jack; MJ-4PP-9
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21, SW22, SW23, SW24, SW26, SW28, SW29, SW30, SW31: SW_Push; MXOnly-1U-Hotswap
SW7: SW_Push; MXOnly-1.5U-Hotswap
SW13: SW_Push; MXOnly-1.75U-Hotswap
SW19: SW_Push; MXOnly-2.25U-Hotswap
SW25, SW27: SW_Push; MXOnly-1.25U-Hotswap
SW32: SW_Push; MXOnly-2U-Hotswap-ReversedStabilizers
SW50, SW51: SW_DPDT_x2; SlideSwitch_IS2235
U1, U2: MCP23017_SP; DIP-28_W7.62mm

Connections:
A1: SW50.2 (B), U1.16 (A1), U2.16 (A1)
A2: SW51.2 (B), U1.17 (A2), U2.17 (A2)
GND: C1.2, D1.1 (K), J1.A (GND), J2.A (GND), J3.A (GND), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, SW21.2, SW22.2, SW23.2, SW24.2, SW25.2, SW26.2, SW27.2, SW28.2, SW29.1, SW30.1, SW31.1, SW32.1, SW50.3 (C), SW51.3 (C), U1.10 (VSS), U1.15 (A0), U2.10 (VSS)
unnamed: D1.2 (A), R1.2
SCL: J1.C (SCL), J2.C (SCL), J3.C (SCL), U1.12 (SCL), U2.12 (SCL)
SDA: J1.B (SDA), J2.B (SDA), J3.B (SDA), U1.13 (SDA), U2.13 (SDA)
SW1: SW1.1, U1.28 (GPA7)
SW2: SW2.1, U1.1 (GPB0)
SW3: SW3.1, U1.27 (GPA6)
SW4: SW4.1, U1.2 (GPB1)
SW5: SW5.1, U1.26 (GPA5)
SW6: SW6.1, U1.3 (GPB2)
SW7: SW7.1, U1.25 (GPA4)
SW8: SW8.1, U1.4 (GPB3)
SW9: SW9.1, U1.24 (GPA3)
SW10: SW10.1, U1.5 (GPB4)
SW11: SW11.1, U1.23 (GPA2)
SW12: SW12.1, U1.6 (GPB5)
SW13: SW13.1, U1.22 (GPA1)
SW14: SW14.1, U1.7 (GPB6)
SW15: SW15.1, U1.21 (GPA0)
SW16: SW16.1, U1.8 (GPB7)
SW17: SW17.1, U2.28 (GPA7)
SW18: SW18.1, U2.1 (GPB0)
SW19: SW19.1, U2.27 (GPA6)
SW20: SW20.1, U2.2 (GPB1)
SW21: SW21.1, U2.26 (GPA5)
SW22: SW22.1, U2.3 (GPB2)
SW23: SW23.1, U2.25 (GPA4)
SW24: SW24.1, U2.4 (GPB3)
SW25: SW25.1, U2.24 (GPA3)
SW26: SW26.1, U2.5 (GPB4)
SW27: SW27.1, U2.23 (GPA2)
SW28: SW28.1, U2.6 (GPB5)
SW29: SW29.2, U2.22 (GPA1)
SW30: SW30.2, U2.21 (GPA0)
SW31: SW31.2, SW32.2, U2.7 (GPB6)
VCC: C1.1, J1.D (3V3), J2.D (3V3), J3.D (3V3), R1.1, SW50.1 (A), SW51.1 (A), U1.9 (VDD), U2.9 (VDD), U2.15 (A0)

Board: 2 copper layers, 168.6 x 104.5 mm, 42 parts (0 on the bottom side), 38 nets.

## KiCad design right/right.kicad_pcb

Parts:
C1: C; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D3.0mm
J1, J2, J3: Modulo-Jack; MJ-4PP-9
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW33, SW37: SW_Push; MXOnly-1U-Hotswap
SW17: SW_Push; MXOnly-ISO-HotSwap
SW31: SW_Push; MXOnly-1.75U-Hotswap
SW34, SW35, SW36, SW38: SW_Push; MXOnly-1.25U-Hotswap
SW44: SW_DPDT_x2; SlideSwitch_IS2235
U1, U2, U3: MCP23017_SP; DIP-28_W7.62mm_Socket

Connections:
ADDR: SW44.2 (B), U1.17 (A2), U2.17 (A2), U3.17 (A2)
GND: C1.2, J1.A (GND), J2.A (GND), J3.A (GND), R1.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.1, SW10.1, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.1, SW17.1, SW18.1, SW19.2, SW20.2, SW21.2, SW22.2, SW23.2, SW24.1, SW25.1, SW26.2, SW27.2, SW28.2, SW29.2, SW30.1, SW31.1, SW33.2, SW34.2, SW35.2, SW36.2, SW37.2, SW38.2, SW44.3 (C), U1.10 (VSS), U1.15 (A0), U1.16 (A1), U2.10 (VSS), U2.16 (A1), U3.10 (VSS), U3.15 (A0)
unnamed: D1.1 (K), R1.1
SCK: J1.C (SCL), J2.C (SCL), J3.C (SCL), U1.12 (SCL), U2.12 (SCL), U3.12 (SCL)
SDA: J1.B (SDA), J2.B (SDA), J3.B (SDA), U1.13 (SDA), U2.13 (SDA), U3.13 (SDA)
SW1: SW1.1, U1.24 (GPA3)
SW2: SW2.1, U1.4 (GPB3)
SW3: SW3.1, U1.25 (GPA4)
SW4: SW4.1, U1.3 (GPB2)
SW5: SW5.1, U1.26 (GPA5)
SW6: SW6.1, U1.2 (GPB1)
SW7: SW7.1, U1.27 (GPA6)
SW8: SW8.1, U1.1 (GPB0)
SW9: SW9.2, U1.28 (GPA7)
SW10: SW10.2, U1.8 (GPB7)
SW11: SW11.1, U1.21 (GPA0)
SW12: SW12.1, U1.7 (GPB6)
SW13: SW13.1, U1.22 (GPA1)
SW14: SW14.1, U1.6 (GPB5)
SW15: SW15.1, U1.23 (GPA2)
SW16: SW16.2, U1.5 (GPB4)
SW17: SW17.2, U2.28 (GPA7)
SW18: SW18.2, U3.28 (GPA7)
SW19: SW19.1, U2.25 (GPA4)
SW20: SW20.1, U2.3 (GPB2)
SW21: SW21.1, U2.26 (GPA5)
SW22: SW22.1, U2.2 (GPB1)
SW23: SW23.1, U2.27 (GPA6)
SW24: SW24.2, U2.1 (GPB0)
SW25: SW25.2, U3.24 (GPA3)
SW26: SW26.1, U3.25 (GPA4)
SW27: SW27.1, U3.3 (GPB2)
SW28: SW28.1, U3.26 (GPA5)
SW29: SW29.1, U3.2 (GPB1)
SW30: SW30.2, U3.1 (GPB0)
SW31: SW31.2, U3.27 (GPA6)
SW33: SW33.1, U3.21 (GPA0)
SW34: SW34.1, U3.7 (GPB6)
SW35: SW35.1, U3.22 (GPA1)
SW36: SW36.1, U3.6 (GPB5)
SW37: SW37.1, U3.23 (GPA2)
SW38: SW38.1, U3.5 (GPB4)
VCC: C1.1, D1.2 (A), J1.D (3V3), J2.D (3V3), J3.D (3V3), SW44.1 (A), U1.9 (VDD), U2.9 (VDD), U2.15 (A0), U3.9 (VDD), U3.16 (A1)

Board: 2 copper layers, 206.6 x 104.5 mm, 47 parts (0 on the bottom side), 43 nets.

## Commit log

2019-06-05 init
2019-06-05 left: change address switch to DPDT
2019-06-05 left: ネジ穴を再生
2019-06-06 last commit
2019-06-06 modify left to JIS layout
2019-06-06 modify right to JIS layout
2019-06-06 modify mounting holl
2019-06-07 add left plate data
2019-06-07 move screw
2019-06-12 add sign
2019-06-12 add docs
2019-06-12 add silk
2019-06-12 change TRRS jack footprint to PJ-320D
2019-06-12 cutout TRRS jack place
2019-06-13 shlink cutout
2019-06-13 change stabilizer cutout
2019-06-13 move right drillhole
2019-06-14 move screw holl
2019-07-09 rev1 release
